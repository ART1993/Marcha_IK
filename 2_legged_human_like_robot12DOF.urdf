Commit message: Preparando RL con ángulos

File: 2_legged_human_like_robot12DOF.urdf (robot description, URDF)
Before this commit: robot biped_robot, 9 links, 8 joints
Joints:
- joint left_ankle_joint: axis 0 1 0 -> 1 0 0
- joint right_ankle_joint: axis 0 1 0 -> 1 0 0
