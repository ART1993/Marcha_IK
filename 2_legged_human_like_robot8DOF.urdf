Commit message: Preparar Entrenamiento con Extra DOF

File: 2_legged_human_like_robot8DOF.urdf (robot description, URDF)
Before this commit: robot biped_robot, 7 links, 6 joints
Joints:
- joint right_hip_joint: axis 0 1 0 -> 0 -1 0
